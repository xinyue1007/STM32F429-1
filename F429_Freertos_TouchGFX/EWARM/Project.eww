<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\F429_Freertos_TouchGFX.ewp</path>
  </project>
  <batchBuild />
</workspace>
